<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_7_hier_tx_phy</value></param>
<param><key>category</key><value>IEEE802.15.7</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Hierarchy Block - Tx PHY</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>ninputs</key><value>3</value></param>
</block>
<block>
<key>ieee802_15_7_encode_PSDU</key>
<param><key>id</key><value>ieee802_15_7_encode_PSDU_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>op_mode</key><value>op_mode</value></param>
</block>
<block>
<key>ieee802_15_7_generate_PHR</key>
<param><key>id</key><value>ieee802_15_7_generate_PHR_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_7_generate_preamble</key>
<param><key>id</key><value>ieee802_15_7_generate_preamble_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_7_line_enc</key>
<param><key>id</key><value>ieee802_15_7_line_enc_0</value></param>
</block>
<block>
<key>ieee802_15_7_line_enc</key>
<param><key>id</key><value>ieee802_15_7_line_enc_1</value></param>
</block>
<block>
<key>ieee802_15_7_rll_enc</key>
<param><key>id</key><value>ieee802_15_7_rll_enc_0</value></param>
</block>
<block>
<key>ieee802_15_7_rll_enc</key>
<param><key>id</key><value>ieee802_15_7_rll_enc_1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>op_mode</value></param>
<param><key>label</key><value>Operating mode</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>phy_out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>mac_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_generate_PHR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_generate_preamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_rll_enc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_PHR_0</source_block_id><sink_block_id>ieee802_15_7_rll_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_preamble_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_enc_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_enc_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_enc_0</source_block_id><sink_block_id>ieee802_15_7_line_enc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_enc_1</source_block_id><sink_block_id>ieee802_15_7_line_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ieee802_15_7_encode_PSDU_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
