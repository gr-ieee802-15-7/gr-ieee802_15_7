<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_7_devel_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>op_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("Hello, world")</value></param>
<param><key>period</key><value>300</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>display</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>ninputs</key><value>3</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("Hello, World!")</value></param>
<param><key>num</key><value>1</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_7_encode_PSDU</key>
<param><key>id</key><value>ieee802_15_7_encode_PSDU_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>op_mode</key><value>op_mode</value></param>
</block>
<block>
<key>ieee802_15_7_generate_MAC</key>
<param><key>id</key><value>ieee802_15_7_generate_MAC_0</value></param>
<param><key>dst_addr</key><value>[0x23, 0x23]</value></param>
<param><key>dst_vpan_id</key><value>[0x23, 0x23]</value></param>
<param><key>src_addr</key><value>[0xff, 0xff]</value></param>
<param><key>src_vpan_id</key><value>[0xff, 0xff]</value></param>
</block>
<block>
<key>ieee802_15_7_generate_PHR</key>
<param><key>id</key><value>ieee802_15_7_generate_PHR_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_7_generate_preamble</key>
<param><key>id</key><value>ieee802_15_7_generate_preamble_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_7_line_enc</key>
<param><key>id</key><value>ieee802_15_7_line_enc_0</value></param>
</block>
<block>
<key>ieee802_15_7_line_enc</key>
<param><key>id</key><value>ieee802_15_7_line_enc_1</value></param>
</block>
<block>
<key>ieee802_15_7_rll_enc</key>
<param><key>id</key><value>ieee802_15_7_rll_enc_0</value></param>
</block>
<block>
<key>ieee802_15_7_rll_enc</key>
<param><key>id</key><value>ieee802_15_7_rll_enc_1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_1</source_block_id><sink_block_id>ieee802_15_7_generate_MAC_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_7_generate_MAC_0</sink_block_id><source_key>out</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_generate_PHR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_generate_preamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_encode_PSDU_0</source_block_id><sink_block_id>ieee802_15_7_rll_enc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_MAC_0</source_block_id><sink_block_id>ieee802_15_7_encode_PSDU_0</sink_block_id><source_key>phy out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_PHR_0</source_block_id><sink_block_id>ieee802_15_7_rll_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_preamble_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_enc_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_enc_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_enc_0</source_block_id><sink_block_id>ieee802_15_7_line_enc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_enc_1</source_block_id><sink_block_id>ieee802_15_7_line_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
