<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_7_devel_loopback</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR_dB</value></param>
<param><key>value</key><value>999</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_cor</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>1./(10**(SNR_dB/20.))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>op_mode</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_len</value></param>
<param><key>value</key><value>60*samp_per_sym</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise/2</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/ieee802157.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1</value></param>
<param><key>msg</key><value>pmt.intern("Hello, world!")</value></param>
<param><key>period</key><value>300</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>157</value></param>
</block>
<block>
<key>ieee802_15_7_decode_PHR</key>
<param><key>id</key><value>ieee802_15_7_decode_PHR_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>op_mode</key><value>op_mode</value></param>
</block>
<block>
<key>ieee802_15_7_decode_PSDU</key>
<param><key>id</key><value>ieee802_15_7_decode_PSDU_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_7_detect_FLP</key>
<param><key>id</key><value>ieee802_15_7_detect_FLP_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>min_plateau</key><value>64*samp_per_sym</value></param>
<param><key>threshold</key><value>0.667</value></param>
</block>
<block>
<key>ieee802_15_7_generate_MAC</key>
<param><key>id</key><value>ieee802_15_7_generate_MAC_0</value></param>
<param><key>dst_addr</key><value>[127,127]</value></param>
<param><key>dst_vpan_id</key><value>[0,0]</value></param>
<param><key>src_addr</key><value>[255,255]</value></param>
<param><key>src_vpan_id</key><value>[128,128]</value></param>
</block>
<block>
<key>ieee802_15_7_hier_rx_correlation</key>
<param><key>id</key><value>ieee802_15_7_hier_rx_correlation_0</value></param>
<param><key>len_cor</key><value>len_cor</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
</block>
<block>
<key>ieee802_15_7_hier_tx_phy</key>
<param><key>id</key><value>ieee802_15_7_hier_tx_phy_0</value></param>
<param><key>op_mode</key><value>op_mode</value></param>
</block>
<block>
<key>ieee802_15_7_line_dec</key>
<param><key>id</key><value>ieee802_15_7_line_dec_0</value></param>
</block>
<block>
<key>ieee802_15_7_rll_dec</key>
<param><key>id</key><value>ieee802_15_7_rll_dec_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Input</value></param>
<param><key>marker1</key><value>9</value></param>
<param><key>style1</key><value>3</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Correlation</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Threshold</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ieee802_15_7_detect_FLP_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ieee802_15_7_hier_rx_correlation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_1</source_block_id><sink_block_id>ieee802_15_7_generate_MAC_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_decode_PHR_0</source_block_id><sink_block_id>ieee802_15_7_line_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_decode_PSDU_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_7_detect_FLP_0</source_block_id><sink_block_id>ieee802_15_7_decode_PHR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_generate_MAC_0</source_block_id><sink_block_id>ieee802_15_7_hier_tx_phy_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>ieee802_15_7_hier_rx_correlation_0</source_block_id><sink_block_id>ieee802_15_7_detect_FLP_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_7_hier_tx_phy_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_dec_0</source_block_id><sink_block_id>ieee802_15_7_rll_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_dec_0</source_block_id><sink_block_id>ieee802_15_7_decode_PSDU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
