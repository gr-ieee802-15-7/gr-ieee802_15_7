<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802_15_7_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>op_mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>ieee802_15_7_decode_PHR</key>
<param><key>id</key><value>ieee802_15_7_decode_PHR_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>op_mode</key><value>op_mode</value></param>
</block>
<block>
<key>ieee802_15_7_decode_PSDU</key>
<param><key>id</key><value>ieee802_15_7_decode_PSDU_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_7_detect_FLP</key>
<param><key>id</key><value>ieee802_15_7_detect_FLP_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>min_plateau</key><value>16*samp_per_sym</value></param>
<param><key>threshold</key><value>0.9</value></param>
</block>
<block>
<key>ieee802_15_7_hier_rx_correlation</key>
<param><key>id</key><value>ieee802_15_7_hier_rx_correlation_0</value></param>
<param><key>len_cor</key><value>32</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
</block>
<block>
<key>ieee802_15_7_line_dec</key>
<param><key>id</key><value>ieee802_15_7_line_dec_0</value></param>
</block>
<block>
<key>ieee802_15_7_rll_dec</key>
<param><key>id</key><value>ieee802_15_7_rll_dec_0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>400000</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ieee802_15_7_detect_FLP_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ieee802_15_7_hier_rx_correlation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_decode_PHR_0</source_block_id><sink_block_id>ieee802_15_7_line_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_detect_FLP_0</source_block_id><sink_block_id>ieee802_15_7_decode_PHR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_hier_rx_correlation_0</source_block_id><sink_block_id>ieee802_15_7_detect_FLP_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_15_7_line_dec_0</source_block_id><sink_block_id>ieee802_15_7_rll_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_7_rll_dec_0</source_block_id><sink_block_id>ieee802_15_7_decode_PSDU_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
